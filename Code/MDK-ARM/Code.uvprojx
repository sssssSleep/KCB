# Keil uVision project Code.uvprojx, settings and files
target Code (6160000::V6.16::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Code +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/Driver/Inc;../User/App/Inc;../User/Driver/MPU6050;../User/Driver/MPU6050/eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group USER/Driver/Inc
    ../User/Driver/Inc/: UartDriver.h Demo.h
  group USER/Driver/Src
    ../User/Driver/Src/: UartDriver.c Dome.c
  group USER/App/Inc
    ../User/App/Inc/: statemachine.h
    ../User/Driver/Inc/: Delay.h Print.h
  group USER/App/Src
    ../User/App/Src/: statemachine.c
    ../User/Driver/Src/: Delay.c Print.c
  group USER/Driver/MPU6050
    ../User/Driver/MPU6050/: mpu6050.c mpuiic.c
    ../User/Driver/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
software components: CMSIS:CORE 5.5.0
